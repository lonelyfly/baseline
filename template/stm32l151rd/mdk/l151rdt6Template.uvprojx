# Keil uVision project l151rdt6Template.uvprojx, settings and files
target l151rdt6Template (6180000::V6.18::ARMCLANG)
  device: STM32L151RD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: l151rdt6Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32L151xD
  c include: ..\..\..\bsp\stm32l151rdTemplate\Inc;..\..\..\hal\st\STM32CubeL1\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\hal\st\STM32CubeL1\Drivers\STM32L1xx_HAL_Driver\IncLegacy;..\..\..\hal\st\STM32CubeL1\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\hal\st\STM32CubeL1\Drivers\CMSIS\Include;..\..\..\CMSIS\CMSIS_RTX\Include;..\..\..\hal\st\STM32CubeL1\Drivers\CMSIS\RTOS2\Include
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ../../../hal/st/STM32CubeL1/Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xd.s
  group Application/User/Core
    ../../../bsp/stm32l151rdTemplate/Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_hal_timebase_tim.c stm32l1xx_it.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../hal/st/STM32CubeL1/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c
  group Drivers/CMSIS
    ../../../hal/st/STM32CubeL1/Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group rtos/rtx5
    ../../../CMSIS/CMSIS_RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
software components: CMSIS:CORE 5.6.0
